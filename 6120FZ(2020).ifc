Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-08T15:34:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 15:34:20 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{C5E24C65-41E3-4044-A0FA-4A7876372EC4}\ifc * Database version: 5507 * Database creation date: Wed Apr 08 15:34:20 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 15:34:20 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 15:34:20 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6120FZ Washbasin faucet, 9/12 V, Bluetooth, 6120FZ(2020):6120FZ Washbasin faucet, 9/12 V, Bluetooth:348972
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 96 mm
Type - Electrical(Type) - Bluetooth: 4.x; Electrical Connection: 9 / 12 V; Electronic Parts: Autofocus sensor;Solenoid valve;; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6120FZ(2020); ConvergoRefNr: 0087-2003-0013-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 02/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150095825; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6110297; Noise Class: I (ISO 3822); NRF Number: 4203697; RSK Number: 8430597; VVS Number: 704276204
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/6120FZ; Catalog Drawing URL: http://static.oras.com/catdrw/6120FZ; Class: Touchless;Bluetooth®;Separate transformer;Plug transformer; Dimension Drawing URL: http://static.oras.com/dimdrw/6120FZ; FDV Document URL: http://www.oras.com/datasheet/6120FZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6120FZ; Group: Washbasin Faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 6120FZ Washbasin faucet, 9/12 V, Bluetooth; Name_en: 6120FZ Washbasin faucet, 9/12 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 210 x 90; Package Weight: 1.582 kg; Product Code: 6120FZ; Product Datasheet: http://www.oras.com/datasheet/6120FZ/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6120FZ; Product URL: http://static.oras.com/6120FZ; Type Name: 6120FZ Washbasin faucet, 9/12 V, Bluetooth
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (via bluetooth);Convertible for cold and premixed-water; Aerator: Pressure controlled aerator;CASCADE®; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible Inlet Pipes; Connection Size: G3/8; DN Size: DN15; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.oras.com/manual/6120FZ; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Non-return valve(s);Litter filter(s);Mixing valve; Mounting Holes: 1 Mounting Hole; Pressure Loss With Flow 01ls: 200000 Pa; Protection Class: IP 55; Spare Parts: http://static.oras.com/sp/6120FZ; Spout Type: Fixed spout; Temperature: Temperature fixable
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Public & Semi-public; CodePerformance: n/a; Color: Chrome; Constituents: Single lever; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6120FZ(2020); Features: Touchless;Bluetooth®;Separate transformer;Plug transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6120FZ; Name: 6120FZ Washbasin faucet, 9/12 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 65x140x120 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6120FZ; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6120FZ Washbasin faucet, 9/12 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.034902 m2; Volume: 0.00110126 m3
Identity Data - Mark: 14
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6120FZ(2020): 6120FZ Washbasin faucet, 9/12 V, Bluetooth; Family and Type: 6120FZ(2020): 6120FZ Washbasin faucet, 9/12 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6120FZ(2020): 6120FZ Washbasin faucet, 9/12 V, Bluetooth; Type Id: 6120FZ(2020): 6120FZ Washbasin faucet, 9/12 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
